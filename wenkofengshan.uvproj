# Keil uVision project wenkofengshan.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: wenkofengshan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c DS18b20.c delay.c delay.h onewire.c onewire.h DS18b20.h LCD1602.h key.c key.h timer.c timer.h AT24C02.c AT24C02.h I2C.c I2C.h Int0.c Int0.h IR.c IR.h
